v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_digital/schem/programmable_nfet.sym} -30 0 0 0 {name=x1 width=0.22u length=0.28u nf=1 mult=1}
