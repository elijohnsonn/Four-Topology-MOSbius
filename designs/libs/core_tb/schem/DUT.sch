v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 -230 180 -230 690 {}
L 4 -1030 180 -1030 690 {}
L 4 -1030 180 -230 180 {}
L 4 100 940 100 1590 {}
L 4 100 1590 1430 1590 {}
L 4 1430 870 1430 1590 {}
L 4 100 870 1430 870 {}
L 4 100 870 100 950 {}
L 4 740 170 740 590 {}
L 4 20 590 740 590 {}
L 4 20 180 20 590 {}
L 4 20 170 740 170 {}
L 4 20 170 20 180 {}
L 4 -230 180 -230 690 {}
L 4 -1030 180 -1030 690 {}
L 4 -1030 180 -230 180 {}
L 4 -1030 690 -240 690 {}
L 4 -240 690 -230 690 {}
L 4 -80 870 -80 880 {}
L 4 -1240 2080 -80 2080 {}
L 4 -1240 870 -1240 2080 {}
L 4 -1240 870 -80 870 {}
L 4 -80 880 -80 2080 {}
L 4 1630 760 1630 1710 {}
L 4 1630 760 2890 760 {}
L 4 2890 760 2890 1710 {}
L 4 1630 1710 1630 2140 {}
L 4 2890 1700 2890 2140 {}
L 4 1630 2140 2890 2140 {}
T {PROGRAMMING ENABLE} -990 770 0 0 1 1 {}
T {CORE AMPLIFIERS} 530 780 0 0 1 1 {}
T {BIAS AND POWER PINS} 100 80 0 0 1 1 {}
T {SCAN CHAIN} -770 90 0 0 1 1 {}
T {SECONDARY ESD} 2030 670 0 0 1 1 {}
T {DECAP} 310 240 0 0 0.5 0.5 {}
N 570 1070 600 1070 {lab=OUT_FOLDED}
N 1220 1090 1270 1090 {lab=OUT_5T}
N 1200 1380 1250 1380 {lab=OUT_CS}
N 1150 1310 1150 1340 {lab=VDD}
N 470 1270 470 1300 {lab=VDD}
N 460 970 460 1000 {lab=VDD}
N 1100 970 1100 1000 {lab=VDD}
N 660 380 660 440 {lab=VDD}
N 540 380 540 440 {lab=VSS}
N 500 1430 500 1470 {lab=IBIAS_PROT}
N 1090 1450 1090 1500 {lab=IBIAS_PROT}
N 460 1140 460 1170 {lab=VSS}
N 1100 1180 1100 1210 {lab=VSS}
N 1150 1420 1150 1470 {lab=VSS}
N 150 360 150 400 {lab=IBIAS_PROT}
N 150 400 150 420 {lab=IBIAS_PROT}
N 150 390 220 390 {lab=IBIAS_PROT}
N 220 390 220 450 {lab=IBIAS_PROT}
N 190 450 220 450 {lab=IBIAS_PROT}
N 150 480 150 520 {lab=VSS}
N 80 450 150 450 {lab=VSS}
N 80 450 80 500 {lab=VSS}
N 80 500 150 500 {lab=VSS}
N 150 520 150 540 {lab=VSS}
N 150 330 150 360 {lab=IBIAS_PROT}
N 220 450 280 450 {lab=IBIAS_PROT}
N 490 1130 490 1160 {lab=IBIAS_PROT}
N 1150 1170 1150 1210 {lab=IBIAS_PROT}
N 470 1440 470 1480 {lab=VSS}
N 350 1420 420 1420 {lab=INN_TELESCOPIC_PROT}
N 340 1320 420 1320 {lab=EN_0_TELESCOPIC}
N 340 1120 410 1120 {lab=INN_FOLDED_PROT}
N 340 1100 410 1100 {lab=INP_FOLDED_PROT}
N 950 1170 990 1170 {lab=INN_5T_PROT}
N 950 1110 990 1110 {lab=INP_5T_PROT}
N -860 340 -800 340 {lab=CLK}
N -420 340 -380 340 {lab=SCAN_OUT}
N -750 470 -750 510 {lab=EN_0_FOLDED}
N -730 470 -730 510 {lab=!EN_0_FOLDED}
N -710 470 -710 510 {lab=EN_1_FOLDED}
N -690 470 -690 510 {lab=!EN_1_FOLDED}
N 340 1020 410 1020 {lab=EN_0_FOLDED}
N 340 1040 410 1040 {lab=!EN_0_FOLDED}
N 340 1060 410 1060 {lab=EN_1_FOLDED}
N 340 1080 410 1080 {lab=!EN_1_FOLDED}
N 340 1340 420 1340 {lab=!EN_0_TELESCOPIC}
N 340 1360 420 1360 {lab=EN_1_TELESCOPIC}
N 340 1380 420 1380 {lab=!EN_1_TELESCOPIC}
N 340 1400 420 1400 {lab=INP_TELESCOPIC_PROT}
N 970 1010 990 1010 {lab=EN_0_5T}
N 970 1030 990 1030 {lab=!EN_0_5T}
N 970 1050 990 1050 {lab=EN_1_5T}
N 970 1070 990 1070 {lab=!EN_1_5T}
N 1010 1340 1040 1340 {lab=EN_0_CS}
N 1010 1350 1040 1350 {lab=!EN_0_CS}
N 1010 1360 1040 1360 {lab=EN_1_CS}
N 1010 1370 1040 1370 {lab=!EN_1_CS}
N 1010 1330 1010 1340 {lab=EN_0_CS}
N 1010 1370 1010 1380 {lab=!EN_1_CS}
N 1000 1380 1010 1380 {lab=!EN_1_CS}
N 910 1360 1010 1360 {lab=EN_1_CS}
N 910 1360 910 1400 {lab=EN_1_CS}
N 910 1350 1010 1350 {lab=!EN_0_CS}
N 910 1310 910 1350 {lab=!EN_0_CS}
N 1000 1330 1010 1330 {lab=EN_0_CS}
N -710 270 -710 300 {lab=VSS}
N -480 270 -480 300 {lab=VDD}
N -670 470 -670 510 {lab=EN_0_TELESCOPIC}
N -650 470 -650 510 {lab=!EN_0_TELESCOPIC}
N -630 470 -630 510 {lab=EN_1_TELESCOPIC}
N -610 470 -610 510 {lab=!EN_1_TELESCOPIC}
N -590 470 -590 510 {lab=EN_0_5T}
N -570 470 -570 510 {lab=!EN_0_5T}
N -550 470 -550 510 {lab=EN_1_5T}
N -530 470 -530 510 {lab=!EN_1_5T}
N -510 470 -510 510 {lab=EN_0_CS}
N -490 470 -490 510 {lab=!EN_0_CS}
N -470 470 -470 510 {lab=EN_1_CS}
N -450 470 -450 510 {lab=!EN_1_CS}
N 580 1370 610 1370 {lab=OUT_TELESCOPIC}
N 1030 1410 1040 1410 {lab=IN_CS_PROT}
N -870 360 -810 360 {lab=SCAN_IN}
N -810 360 -800 360 {lab=SCAN_IN}
N -880 990 -830 990 {lab=PROG_ENA}
N -660 980 -590 980 {lab=!PROG_ENA}
N -780 1030 -780 1070 {lab=VSS}
N -780 920 -780 950 {lab=VDD}
N -980 1150 -980 1190 {lab=PROG_ENA}
N -980 1260 -980 1300 {lab=!PROG_ENA}
N -1030 1160 -1030 1190 {lab=VDD}
N -1020 1290 -1020 1330 {lab=VSS}
N -900 1240 -810 1240 {lab=EN_0_FOLDED}
N -1150 1240 -1070 1240 {lab=VSS}
N -440 1150 -440 1190 {lab=PROG_ENA}
N -440 1260 -440 1300 {lab=!PROG_ENA}
N -490 1160 -490 1190 {lab=VDD}
N -480 1290 -480 1330 {lab=VSS}
N -360 1240 -270 1240 {lab=EN_1_FOLDED}
N -610 1240 -530 1240 {lab=VSS}
N -980 1410 -980 1450 {lab=PROG_ENA}
N -980 1520 -980 1560 {lab=!PROG_ENA}
N -1030 1420 -1030 1450 {lab=VDD}
N -1020 1550 -1020 1590 {lab=VSS}
N -900 1500 -810 1500 {lab=EN_0_TELESCOPIC}
N -1150 1500 -1070 1500 {lab=VSS}
N -440 1410 -440 1450 {lab=PROG_ENA}
N -440 1520 -440 1560 {lab=!PROG_ENA}
N -490 1420 -490 1450 {lab=VDD}
N -480 1550 -480 1590 {lab=VSS}
N -360 1500 -270 1500 {lab=EN_1_TELESCOPIC}
N -610 1500 -530 1500 {lab=VSS}
N -980 1640 -980 1680 {lab=PROG_ENA}
N -980 1750 -980 1790 {lab=!PROG_ENA}
N -1030 1650 -1030 1680 {lab=VDD}
N -1020 1780 -1020 1820 {lab=VSS}
N -900 1730 -810 1730 {lab=EN_0_5T}
N -1150 1730 -1070 1730 {lab=VSS}
N -440 1640 -440 1680 {lab=PROG_ENA}
N -440 1750 -440 1790 {lab=!PROG_ENA}
N -490 1650 -490 1680 {lab=VDD}
N -480 1780 -480 1820 {lab=VSS}
N -360 1730 -270 1730 {lab=EN_1_5T}
N -610 1730 -530 1730 {lab=VSS}
N -980 1860 -980 1900 {lab=PROG_ENA}
N -980 1970 -980 2010 {lab=!PROG_ENA}
N -1030 1870 -1030 1900 {lab=VDD}
N -1020 2000 -1020 2040 {lab=VSS}
N -900 1950 -810 1950 {lab=EN_0_CS}
N -1150 1950 -1070 1950 {lab=VSS}
N -440 1860 -440 1900 {lab=PROG_ENA}
N -440 1970 -440 2010 {lab=!PROG_ENA}
N -490 1870 -490 1900 {lab=VDD}
N -480 2000 -480 2040 {lab=VSS}
N -360 1950 -270 1950 {lab=EN_1_CS}
N -610 1950 -530 1950 {lab=VSS}
N 450 280 450 300 {lab=VSS}
N 450 210 450 220 {lab=VDD}
C {libs/core_digital/schem/scan_chain.sym} -610 430 0 0 {name=x1}
C {libs/core_amps/ota_folded_cascode/prgrm_schem/programmable_folded_cascode.sym} 430 1070 0 0 {name=x2}
C {libs/core_amps/cs_stage/prgrm_schem/programmable_common_source.sym} 1060 1380 0 0 {name=x5}
C {lab_pin.sym} 660 380 0 0 {name=p36 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 540 380 0 0 {name=p37 sig_type=std_logic lab=VSS}
C {iopin.sym} 540 440 1 0 {name=p38 lab=VSS}
C {iopin.sym} 660 440 1 0 {name=p39 lab=VDD}
C {lab_pin.sym} 460 970 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1100 970 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 470 1270 0 0 {name=p6 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1150 1310 0 0 {name=p7 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 460 1170 0 0 {name=p8 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 470 1480 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1150 1470 0 1 {name=p10 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1100 1210 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {symbols/nfet_03v3.sym} 170 450 0 1 {name=M1
L=1u
W=27.1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 280 450 0 1 {name=p12 sig_type=std_logic lab=IBIAS_PROT}
C {lab_pin.sym} 500 1470 0 1 {name=p13 sig_type=std_logic lab=IBIAS_PROT}
C {iopin.sym} -860 340 2 0 {name=p28 lab=CLK}
C {iopin.sym} -870 360 2 0 {name=p29 lab=SCAN_IN}
C {iopin.sym} -380 340 2 1 {name=p30 lab=SCAN_OUT}
C {lab_pin.sym} -750 510 3 0 {name=p15 sig_type=std_logic lab=EN_0_FOLDED}
C {lab_pin.sym} 340 1020 2 1 {name=p31 sig_type=std_logic lab=EN_0_FOLDED}
C {lab_pin.sym} -730 510 3 0 {name=p32 sig_type=std_logic lab=!EN_0_FOLDED}
C {lab_pin.sym} 340 1040 2 1 {name=p33 sig_type=std_logic lab=!EN_0_FOLDED}
C {lab_pin.sym} -710 510 3 0 {name=p34 sig_type=std_logic lab=EN_1_FOLDED}
C {lab_pin.sym} 340 1060 0 0 {name=p40 sig_type=std_logic lab=EN_1_FOLDED}
C {lab_pin.sym} -690 510 3 0 {name=p41 sig_type=std_logic lab=!EN_1_FOLDED}
C {lab_pin.sym} 340 1080 0 0 {name=p42 sig_type=std_logic lab=!EN_1_FOLDED}
C {lab_pin.sym} 340 1320 2 1 {name=p43 sig_type=std_logic lab=EN_0_TELESCOPIC}
C {lab_pin.sym} 340 1340 2 1 {name=p44 sig_type=std_logic lab=!EN_0_TELESCOPIC}
C {lab_pin.sym} 340 1360 0 0 {name=p45 sig_type=std_logic lab=EN_1_TELESCOPIC}
C {lab_pin.sym} 340 1380 0 0 {name=p46 sig_type=std_logic lab=!EN_1_TELESCOPIC}
C {lab_pin.sym} 970 1010 2 1 {name=p47 sig_type=std_logic lab=EN_0_5T}
C {lab_pin.sym} 970 1030 2 1 {name=p48 sig_type=std_logic lab=!EN_0_5T}
C {lab_pin.sym} 970 1050 0 0 {name=p49 sig_type=std_logic lab=EN_1_5T}
C {lab_pin.sym} 970 1070 0 0 {name=p50 sig_type=std_logic lab=!EN_1_5T}
C {lab_pin.sym} 1000 1330 2 1 {name=p51 sig_type=std_logic lab=EN_0_CS}
C {lab_pin.sym} 1000 1380 0 0 {name=p52 sig_type=std_logic lab=!EN_1_CS}
C {lab_pin.sym} 910 1400 0 0 {name=p53 sig_type=std_logic lab=EN_1_CS}
C {lab_pin.sym} 910 1310 2 1 {name=p54 sig_type=std_logic lab=!EN_0_CS}
C {lab_pin.sym} -710 270 0 0 {name=p55 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -480 270 0 0 {name=p56 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -670 510 3 0 {name=p57 sig_type=std_logic lab=EN_0_TELESCOPIC}
C {lab_pin.sym} -650 510 3 0 {name=p58 sig_type=std_logic lab=!EN_0_TELESCOPIC}
C {lab_pin.sym} -630 510 3 0 {name=p59 sig_type=std_logic lab=EN_1_TELESCOPIC}
C {lab_pin.sym} -610 510 3 0 {name=p60 sig_type=std_logic lab=!EN_1_TELESCOPIC}
C {lab_pin.sym} -590 510 3 0 {name=p61 sig_type=std_logic lab=EN_0_5T}
C {lab_pin.sym} -570 510 3 0 {name=p62 sig_type=std_logic lab=!EN_0_5T}
C {lab_pin.sym} -550 510 3 0 {name=p63 sig_type=std_logic lab=EN_1_5T}
C {lab_pin.sym} -530 510 3 0 {name=p64 sig_type=std_logic lab=!EN_1_5T}
C {lab_pin.sym} -510 510 3 0 {name=p65 sig_type=std_logic lab=EN_0_CS}
C {lab_pin.sym} -490 510 3 0 {name=p66 sig_type=std_logic lab=!EN_0_CS}
C {lab_pin.sym} -470 510 3 0 {name=p67 sig_type=std_logic lab=EN_1_CS}
C {lab_pin.sym} -450 510 3 0 {name=p68 sig_type=std_logic lab=!EN_1_CS}
C {libs/core_amps/ota_5t/prgram_schem/programmable_5tOTA.sym} 1140 1090 0 0 {name=x3}
C {lab_pin.sym} 1090 1500 0 0 {name=p20 sig_type=std_logic lab=IBIAS_PROT}
C {lab_pin.sym} 1150 1210 0 1 {name=p19 sig_type=std_logic lab=IBIAS_PROT}
C {lab_pin.sym} 490 1160 0 1 {name=p17 sig_type=std_logic lab=IBIAS_PROT}
C {lab_pin.sym} 150 540 0 0 {name=p16 sig_type=std_logic lab=VSS}
C {iopin.sym} -880 990 2 0 {name=p14 lab=PROG_ENA}
C {libs/core_digital/schem/inv1.sym} -770 1000 0 0 {name=x6}
C {lab_pin.sym} -780 920 0 0 {name=p18 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -780 1070 0 0 {name=p69 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -590 980 0 1 {name=p71 sig_type=std_logic lab=!PROG_ENA
}
C {libs/core_digital/schem/transmission_gate.sym} -980 1240 0 0 {name=x7}
C {lab_pin.sym} -1030 1160 0 0 {name=p72 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1020 1330 0 0 {name=p73 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -1150 1240 0 0 {name=p74 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -980 1300 0 1 {name=p75 sig_type=std_logic lab=!PROG_ENA
}
C {lab_pin.sym} -980 1150 0 1 {name=p76 sig_type=std_logic lab=PROG_ENA
}
C {lab_pin.sym} -810 1240 0 1 {name=p77 sig_type=std_logic lab=EN_0_FOLDED
}
C {libs/core_digital/schem/transmission_gate.sym} -440 1240 0 0 {name=x8}
C {lab_pin.sym} -490 1160 0 0 {name=p78 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -480 1330 0 0 {name=p79 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -610 1240 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -440 1300 0 1 {name=p81 sig_type=std_logic lab=!PROG_ENA
}
C {lab_pin.sym} -440 1150 0 1 {name=p82 sig_type=std_logic lab=PROG_ENA
}
C {lab_pin.sym} -270 1240 0 1 {name=p83 sig_type=std_logic lab=EN_1_FOLDED
}
C {libs/core_digital/schem/transmission_gate.sym} -980 1500 0 0 {name=x9}
C {lab_pin.sym} -1030 1420 0 0 {name=p84 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1020 1590 0 0 {name=p85 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -1150 1500 0 0 {name=p86 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -980 1560 0 1 {name=p87 sig_type=std_logic lab=!PROG_ENA
}
C {lab_pin.sym} -980 1410 0 1 {name=p88 sig_type=std_logic lab=PROG_ENA
}
C {lab_pin.sym} -810 1500 0 1 {name=p89 sig_type=std_logic lab=EN_0_TELESCOPIC
}
C {libs/core_digital/schem/transmission_gate.sym} -440 1500 0 0 {name=x10}
C {lab_pin.sym} -490 1420 0 0 {name=p90 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -480 1590 0 0 {name=p91 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -610 1500 0 0 {name=p92 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -440 1560 0 1 {name=p93 sig_type=std_logic lab=!PROG_ENA
}
C {lab_pin.sym} -440 1410 0 1 {name=p94 sig_type=std_logic lab=PROG_ENA
}
C {lab_pin.sym} -270 1500 0 1 {name=p95 sig_type=std_logic lab=EN_1_TELESCOPIC
}
C {libs/core_digital/schem/transmission_gate.sym} -980 1730 0 0 {name=x11}
C {lab_pin.sym} -1030 1650 0 0 {name=p96 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1020 1820 0 0 {name=p97 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -1150 1730 0 0 {name=p98 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -980 1790 0 1 {name=p99 sig_type=std_logic lab=!PROG_ENA
}
C {lab_pin.sym} -980 1640 0 1 {name=p100 sig_type=std_logic lab=PROG_ENA
}
C {lab_pin.sym} -810 1730 0 1 {name=p101 sig_type=std_logic lab=EN_0_5T
}
C {libs/core_digital/schem/transmission_gate.sym} -440 1730 0 0 {name=x12}
C {lab_pin.sym} -490 1650 0 0 {name=p102 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -480 1820 0 0 {name=p103 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -610 1730 0 0 {name=p104 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -440 1790 0 1 {name=p105 sig_type=std_logic lab=!PROG_ENA
}
C {lab_pin.sym} -440 1640 0 1 {name=p106 sig_type=std_logic lab=PROG_ENA
}
C {lab_pin.sym} -270 1730 0 1 {name=p107 sig_type=std_logic lab=EN_1_5T
}
C {libs/core_digital/schem/transmission_gate.sym} -980 1950 0 0 {name=x13}
C {lab_pin.sym} -1030 1870 0 0 {name=p108 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1020 2040 0 0 {name=p109 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -1150 1950 0 0 {name=p110 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -980 2010 0 1 {name=p111 sig_type=std_logic lab=!PROG_ENA
}
C {lab_pin.sym} -980 1860 0 1 {name=p112 sig_type=std_logic lab=PROG_ENA
}
C {lab_pin.sym} -810 1950 0 1 {name=p113 sig_type=std_logic lab=EN_0_CS
}
C {libs/core_digital/schem/transmission_gate.sym} -440 1950 0 0 {name=x14}
C {lab_pin.sym} -490 1870 0 0 {name=p114 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -480 2040 0 0 {name=p115 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -610 1950 0 0 {name=p116 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -440 2010 0 1 {name=p117 sig_type=std_logic lab=!PROG_ENA
}
C {lab_pin.sym} -440 1860 0 1 {name=p118 sig_type=std_logic lab=PROG_ENA
}
C {lab_pin.sym} -270 1950 0 1 {name=p119 sig_type=std_logic lab=EN_1_CS
}
C {libs/core_amps/ota_telescopic/programmable_ota_telescopic_schematics/programmable_telescopic_cascode.sym} 440 1370 0 0 {name=x4}
C {libs/secondary_esd/io_secondary_5p0.sym} 2000 980 0 1 {name=IO1
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2630 980 0 1 {name=IO2
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2000 1210 0 1 {name=IO3
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2630 1210 0 1 {name=IO4
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2000 1440 0 1 {name=IO5
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2630 1440 0 1 {name=IO6
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2000 1670 0 1 {name=IO7
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2630 1670 0 1 {name=IO8
spiceprefix=X
}
C {lab_pin.sym} 2000 900 0 1 {name=p122 sig_type=std_logic lab=INP_FOLDED_PROT}
C {lab_pin.sym} 2630 900 0 1 {name=p123 sig_type=std_logic lab=INN_FOLDED_PROT}
C {lab_pin.sym} 2000 1130 0 1 {name=p125 sig_type=std_logic lab=INP_TELESCOPIC_PROT}
C {lab_pin.sym} 2630 1130 0 1 {name=p127 sig_type=std_logic lab=INN_TELESCOPIC_PROT}
C {lab_pin.sym} 2000 1360 0 1 {name=p129 sig_type=std_logic lab=INP_5T_PROT}
C {lab_pin.sym} 2630 1360 0 1 {name=p131 sig_type=std_logic lab=INN_5T_PROT}
C {lab_pin.sym} 2630 1590 0 1 {name=p133 sig_type=std_logic lab=IBIAS_PROT}
C {lab_pin.sym} 2000 1590 0 1 {name=p135 sig_type=std_logic lab=IN_CS_PROT}
C {iopin.sym} 1800 900 2 0 {name=p121 lab=INP_FOLDED}
C {iopin.sym} 2430 900 2 0 {name=p124 lab=INN_FOLDED}
C {iopin.sym} 1800 1130 2 0 {name=p126 lab=INP_TELESCOPIC}
C {iopin.sym} 1800 1360 2 0 {name=p130 lab=INP_5T}
C {iopin.sym} 2430 1360 2 0 {name=p132 lab=INN_5T}
C {iopin.sym} 1800 1590 2 0 {name=p134 lab=IN_CS}
C {lab_pin.sym} 1920 820 0 0 {name=p21 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2550 820 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1920 1050 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2550 1050 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1920 1280 0 0 {name=p26 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2550 1280 0 0 {name=p27 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1920 1510 0 0 {name=p120 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2550 1510 0 0 {name=p136 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1920 980 0 0 {name=p137 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1920 1210 0 0 {name=p138 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2550 980 0 0 {name=p139 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2550 1210 0 0 {name=p140 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2550 1440 0 0 {name=p141 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1920 1440 0 0 {name=p142 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1920 1670 0 0 {name=p143 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2550 1670 0 0 {name=p144 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 340 1100 0 0 {name=p146 sig_type=std_logic lab=INP_FOLDED_PROT}
C {lab_pin.sym} 340 1120 0 0 {name=p147 sig_type=std_logic lab=INN_FOLDED_PROT}
C {lab_pin.sym} 340 1400 0 0 {name=p148 sig_type=std_logic lab=INP_TELESCOPIC_PROT}
C {iopin.sym} 2430 1130 2 0 {name=p149 lab=INN_TELESCOPIC}
C {lab_pin.sym} 350 1420 0 0 {name=p128 sig_type=std_logic lab=INN_TELESCOPIC_PROT}
C {lab_pin.sym} 950 1110 0 0 {name=p150 sig_type=std_logic lab=INP_5T_PROT}
C {lab_pin.sym} 950 1170 0 0 {name=p151 sig_type=std_logic lab=INN_5T_PROT}
C {lab_pin.sym} 1030 1410 0 0 {name=p152 sig_type=std_logic lab=IN_CS_PROT}
C {iopin.sym} 2430 1590 0 1 {name=p23 lab=IBIAS
}
C {symbols/cap_nmos_03v3_b.sym} 450 250 0 0 {name=C1
W=19.15094e-6
L=20e-6
model=cap_nmos_03v3_b
spiceprefix=X
m=53}
C {lab_pin.sym} 450 210 0 0 {name=p70 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 450 300 0 0 {name=p145 sig_type=std_logic lab=VSS}
C {libs/secondary_esd/io_secondary_5p0.sym} 2000 1890 0 1 {name=IO9
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2630 1890 0 1 {name=IO10
spiceprefix=X
}
C {lab_pin.sym} 2630 1810 0 1 {name=p153 sig_type=std_logic lab=OUT_5T_PROT}
C {lab_pin.sym} 2000 1810 0 1 {name=p154 sig_type=std_logic lab=OUT_CS_PROT}
C {iopin.sym} 1800 1810 2 0 {name=p155 lab=OUT_CS}
C {lab_pin.sym} 1920 1730 0 0 {name=p156 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2550 1730 0 0 {name=p157 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1920 1890 0 0 {name=p158 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2550 1890 0 0 {name=p159 sig_type=std_logic lab=VSS}
C {iopin.sym} 2430 1810 0 1 {name=p160 lab=OUT_5T
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2000 2100 0 1 {name=IO11
spiceprefix=X
}
C {libs/secondary_esd/io_secondary_5p0.sym} 2630 2100 0 1 {name=IO12
spiceprefix=X
}
C {lab_pin.sym} 2630 2020 0 1 {name=p161 sig_type=std_logic lab=OUT_FOLDED_PROT}
C {lab_pin.sym} 2000 2020 0 1 {name=p162 sig_type=std_logic lab=OUT_TELESCOPIC_PROT}
C {iopin.sym} 1800 2020 2 0 {name=p163 lab=OUT_TELESCOPIC}
C {lab_pin.sym} 1920 1940 0 0 {name=p164 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2550 1940 0 0 {name=p165 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1920 2100 0 0 {name=p166 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2550 2100 0 0 {name=p167 sig_type=std_logic lab=VSS}
C {iopin.sym} 2430 2020 0 1 {name=p168 lab=OUT_FOLDED
}
C {lab_pin.sym} 1250 1380 0 1 {name=p1 sig_type=std_logic lab=OUT_CS_PROT}
C {lab_pin.sym} 1270 1090 0 1 {name=p2 sig_type=std_logic lab=OUT_5T_PROT}
C {lab_pin.sym} -110 660 0 1 {name=p3 sig_type=std_logic lab=OUT_CS_PROT}
C {lab_pin.sym} 610 1370 0 1 {name=p35 sig_type=std_logic lab=OUT_TELESCOPIC_PROT}
C {lab_pin.sym} -120 440 0 1 {name=p169 sig_type=std_logic lab=OUT_5T_PROT}
C {lab_pin.sym} -1500 10 0 1 {name=p170 sig_type=std_logic lab=OUT_CS_PROT}
C {lab_pin.sym} 600 1070 0 1 {name=p171 sig_type=std_logic lab=OUT_FOLDED_PROT}
C {lab_pin.sym} -1420 420 0 1 {name=p172 sig_type=std_logic lab=OUT_TELESCOPIC_PROT}
C {lab_pin.sym} -2150 -510 0 1 {name=p173 sig_type=std_logic lab=OUT_5T_PROT}
C {lab_pin.sym} -3530 -940 0 1 {name=p174 sig_type=std_logic lab=OUT_CS_PROT}
