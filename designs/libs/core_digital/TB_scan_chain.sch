v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_digital/scan_chain.sym} -40 30 0 0 {name=x1}
